require xorg-app-common.inc
DESCRIPTION = "X Resize and Rotate extension command."
LICENSE = "BSD-X"
DEPENDS += " libxrandr libxrender "
PE = "1"
PR = "${INC_PR}.0"
LIC_FILES_CHKSUM="file://COPYING;md5=4641deddaa80fe7ca88e944e1fd94a94"
SRC_URI[md5sum] = "9e74e6919cf731ec10ce26fd6a4483fa"
SRC_URI[sha256sum] = "7bf3bd3cf46a6a29e35b9dd1c8d3d14494be76da0d24c6ef5dab36974445004d"
