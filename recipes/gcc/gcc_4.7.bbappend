FILESEXTRAPATHS := "${THISDIR}/gcc-4.7"


SRC_URI += "file://iwmmxt_fix.patch \
			file://iwmmxt_insn_fix.patch"
