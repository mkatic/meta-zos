EXTRA_OECONF := "${@'${EXTRA_OECONF}'.replace('--disable-tui', '')}"
