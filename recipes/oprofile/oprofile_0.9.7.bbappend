TARGET_CC_ARCH = "-march=armv5te -mtune=xscale"
