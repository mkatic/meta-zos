SYSVINIT_ENABLED_GETTYS = "1 2 3"
