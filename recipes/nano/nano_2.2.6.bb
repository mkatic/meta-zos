include nano.inc

PR = "${INC_PR}.0"

#SRC_URI += "file://ncursesw.includedir.patch"

SRC_URI[md5sum] = "03233ae480689a008eb98feb1b599807"
SRC_URI[sha256sum] = "be68e133b5e81df41873d32c517b3e5950770c00fc5f4dd23810cd635abce67a"
