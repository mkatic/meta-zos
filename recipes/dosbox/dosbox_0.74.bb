require dosbox.inc

LIC_FILES_CHKSUM="file://COPYING;md5=94d55d512a9ba36caa9b7df079bae19f"

SRC_URI[md5sum] = "b9b240fa87104421962d14eee71351e8"
SRC_URI[sha256sum] = "13f74916e2d4002bad1978e55727f302ff6df3d9be2f9b0e271501bd0a938e05"

