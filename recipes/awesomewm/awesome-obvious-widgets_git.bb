DESCRIPTION = "The Obvious Repository is a set of widgets for your awesome desktop that provide helpful information"
SECTION = "X11/libs"
PRIORITY = "optional"
DEPENDS = "awesome"
LICENSE = "MIT"
LIC_FILES_CHKSUM=""
PR = "r0"

DEFAULT_PREFERENCE="-1" 

SRC_URI="git://git.mercenariesguild.net/obvious.git;tag=master"

S="${WORKDIR}/git"
