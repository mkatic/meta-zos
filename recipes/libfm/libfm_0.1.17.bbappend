FILESEXTRAPATHS := "${THISDIR}/files"

SRC_URI =+ "file://remove_icon.patch"
